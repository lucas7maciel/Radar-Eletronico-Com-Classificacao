## tests/unit/testcase.yaml
```yaml
tests:
  radar.unit:
    platform_allow:
      - native_sim
    tags: radar ztest
```
